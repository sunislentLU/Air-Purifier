# Keil uVision project AP_C120_Boot.uvprojx, settings and files
target Boot (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AP_C120_Boot
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F0xx_StdPeriph_Driver\inc;..\src;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Lib
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_iwdg.c stm32f0xx_i2c.c
  group usr
    ../src/: main.c stm32f0xx_it.c hardware.c
