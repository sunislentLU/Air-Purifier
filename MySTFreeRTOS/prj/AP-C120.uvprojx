# Keil uVision project AP-C120.uvprojx, settings and files
target AP-C120 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AP-C120
  AfterMake: fromelf.exe --bin -o ../bin/app.bin  ../prj/Objects/AP-C120.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FreeRTOS_include;..\STM32F0xx_StdPeriph_Driver\inc;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F0xx\Include;..\usr;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xd800
  memory RVCT9: RAM 0x200000c0 size 0x2000
  group startUp
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group lib
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group freeRTOS
    ../FreeRTOS_Source/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
  group user
    ../usr/: main.c stm32f0xx_it.c wifiProtocol.c fifo.c
  group task
    ../Task/: device_inputTask.c device_outputTask.c mainTask.c wifi_Task.c
  group bsp
    ../bsp/: bspInput.c bspOutput.c bspWifi.c key.c
    ../usr/: hdc1080.c pms7003i.c
